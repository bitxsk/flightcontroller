# IAR project project_K60F12.ewp, settings and files
configuration FLASH (ARM, debug)
  General.OGChipSelectEditMenu: MK60FX512xxx12 NXP MK60FX512xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: K60; USE_K60F15; ARM_MATH_CM4; __FPU_PRESENT=1; __FPU_USED=1
  ICCARM.CCIncludePath2: ..\app; ..\app\Sensor; ..\lib\CPU; ..\lib\common; ..\lib\LPLD; ..\lib\LPLD\HW; ..\lib\LPLD\DEV; ..\lib\LPLD\FUNC; ..\lib\uCOS-II\Ports; ..\lib\uCOS-II\Source; ..\lib\FatFs; ..\lib\FatFs\option; ..\lib\USB\common; ..\lib\USB\driver; ..\lib\USB\descriptor; ..\lib\USB\class
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 1
  OBJCOPY.OOCOutputFile: project_K60F12.bin
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ..\lib\iar_config_files\LPLD_K60FN1M0_FLASH.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group app
    ../app/: AHRS.c AHRS.h control.c control.h EKF_AHRS.cpp EKF_AHRS.h EVB.c EVB.h FlightMode.cpp FlightMode.h fuzzyPID.c fuzzyPID.h General Class.cpp General Class.h history AHRS data.c history AHRS data.h includes.h isr.c isr.h MadgwickAHRS.c MadgwickAHRS.h moduleInit.c moduleInit.h project.c variables.h variables_F450.c variables_F450_raw.c variables_QAV220.c variables_QAV250.c
    ../app/Sensor/: Navigation.cpp Navigation.h
  group app/Sensor
    ../app/: ADXL355.cpp ADXL355.h ADXRS453.c ADXRS453.h Beep.cpp Beep.h Ftm1.c Ftm1.h GPS.cpp GPS.h LidarLite.cpp LidarLite.h NvidiaTX1.cpp NvidiaTX1.h Odom.c Odom.h SBus.cpp SBus.h Ultrasound(UART).cpp Ultrasound(UART).h waterGun.cpp waterGun.h
    ../app/Sensor/: HMC5983.cpp HMC5983.h MPU6000.cpp MPU6000.h MS5611 Air Pressure.cpp MS5611 Air Pressure.h RemoteHub.cpp RemoteHub.h Ultrasound.cpp Ultrasound.h VideoStation.cpp VideoStation.h
  group app/Sensor/INF_I-UWB
    ../app/Sensor/: UWB decode.cpp UWB decode.h
  group lib
    ../app/: k60_card.h
  group lib/common
    ../lib/common/: assert.c assert.h common.h io.c io.h lib_def.h memtest.c memtest.h printf.c queue.c queue.h relocate.c relocate.h uif.c uif.h
  group lib/CPU
    ../lib/CPU/: startup_K60F12.s system_MK60.c
  group lib/LPLD/Drive
    ../lib/LPLD/DEV/: DEV_LCD.c DEV_LCD.h
    ../lib/LPLD/: LPLD_Drivers.h
  group lib/LPLD/HW
    ../lib/LPLD/HW/: ADC.c ADC.h DMA.c DMA.h FLASH.c FLASH.h FLEXBUS.c FLEXBUS.h FTM.c FTM.h GPIO.c GPIO.h I2C.c I2C.h LPTMR.c LPTMR.h MCG.c MCG.h PIT.c PIT.h RTC.c RTC.h SPI.c SPI.h UART.c UART.h
