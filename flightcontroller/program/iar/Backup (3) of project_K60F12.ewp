# IAR project Backup (3) of project_K60F12.ewp, settings and files
configuration RAM (ARM, debug)
  General.OGChipSelectEditMenu: MK60FX512xxx15 Freescale MK60FX512xxx15
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: LPLD_K60; USE_K60F15; ARM_MATH_CM4; __FPU_PRESENT=1; __FPU_USED=1
  ICCARM.CCIncludePath2: ..\app; ..\app\Sensor; ..\lib\CPU; ..\lib\common; ..\lib\LPLD; ..\lib\LPLD\HW; ..\lib\LPLD\DEV; ..\lib\LPLD\FUNC; ..\lib\uCOS-II\Ports; ..\lib\uCOS-II\Source; ..\lib\FatFs; ..\lib\FatFs\option; ..\lib\USB\common; ..\lib\USB\driver; ..\lib\USB\descriptor; ..\lib\USB\class
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 1
  OBJCOPY.OOCOutputFile: project_K60F12.bin
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ..\..\..\lib\iar_config_files\LPLD_K60DN512_RAM.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration FLASH (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MK60FX512xxx12 NXP MK60FX512xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: K60; USE_K60F15; ARM_MATH_CM4; __FPU_PRESENT=1; __FPU_USED=1
  ICCARM.CCOptStrategy: 1
  ILINK.IlinkIcfFile: ..\lib\iar_config_files\LPLD_K60FN1M0_FLASH.icf
configuration BOOT (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MK60FN1M0xxx12 Freescale MK60FN1M0xxx12
  ICCARM.CCDefines: LPLD_K60; USE_K60F12
  ICCARM.CCIncludePath2: ..\app; ..\..\..\lib\CPU; ..\..\..\lib\common; ..\..\..\lib\LPLD; ..\..\..\lib\LPLD\HW; ..\..\..\lib\LPLD\DEV; ..\..\..\lib\LPLD\FUNC; ..\..\..\lib\uCOS-II\Ports; ..\..\..\lib\uCOS-II\Source; ..\..\..\lib\FatFs; ..\..\..\lib\FatFs\option; ..\..\..\lib\USB\common; ..\..\..\lib\USB\driver; ..\..\..\lib\USB\descriptor; ..\..\..\lib\USB\class
  ICCARM.CCOptLevel: 1
  ICCARM.IccLang: 0
  ILINK.IlinkIcfFile: ..\..\..\lib\iar_config_files\LPLD_K60FN1M0_BOOT.icf
  group app
    ../app/: control.c control.h EKF_AHRS.cpp EKF_AHRS.h EVB.c EVB.h fuzzyPID.c fuzzyPID.h General Class.cpp General Class.h history AHRS data.c history AHRS data.h includes.h isr.c isr.h k60_card.h MadgwickAHRS.c MadgwickAHRS.h moduleInit.c moduleInit.h project.c variables.h variables_F450.c variables_QAV250.c
  group app/Sensor
    ../app/: Beep.cpp Beep.h LidarLite.cpp LidarLite.h NvidiaTX1.cpp NvidiaTX1.h
    ../app/Sensor/: HMC5983.cpp HMC5983.h MPU6000.cpp MPU6000.h MS5611 Air Pressure.cpp MS5611 Air Pressure.h Ultrasound.cpp Ultrasound.h
  group lib/common
    ../lib/common/: assert.c assert.h common.h io.c io.h lib_def.h memtest.c memtest.h printf.c queue.c queue.h relocate.c relocate.h uif.c uif.h
  group lib/CPU
    ../lib/CPU/: startup_K60F12.s system_MK60.c
  group lib/LPLD/Drive
    ../lib/LPLD/DEV/: DEV_LCD.c DEV_LCD.h
    ../lib/LPLD/: LPLD_Drivers.h
  group lib/LPLD/HW
    ../lib/LPLD/HW/: ADC.c ADC.h DMA.c DMA.h FLASH.c FLASH.h FLEXBUS.c FLEXBUS.h FTM.c FTM.h GPIO.c GPIO.h I2C.c I2C.h LPTMR.c LPTMR.h MCG.c MCG.h PIT.c PIT.h RTC.c RTC.h SPI.c SPI.h UART.c UART.h
